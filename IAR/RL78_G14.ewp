# IAR project RL78_G14.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F104BG RL78 - R5F104BG
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  General.GenHugeHeapSize: 0
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: src\adc; src\base; src\intc; src\ports; src\serial; src\timers
  OBJCOPY.OOCOutputFile: RL78_G14.srec
  ILINK.IlinkOutputFile: RL78_G14.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: NDEBUG
  group (top)
    src/adc/: r_cg_adc.c r_cg_adc_user.c
    src/base/: r_cg_cgc.c r_cg_cgc_user.c r_main.c r_systeminit.c
    src/intc/: r_cg_intc.c r_cg_intc_user.c
    src/ports/: r_cg_port.c r_cg_port_user.c
    src/serial/: r_cg_serial.c r_cg_serial_user.c
    src/timers/: r_cg_timer.c r_cg_timer_user.c
